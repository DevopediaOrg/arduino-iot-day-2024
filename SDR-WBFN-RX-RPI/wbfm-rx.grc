options:
  parameters:
    author: Devopedia
    category: Custom
    comment: 'Original author: John Petrich, W7FU'
    description: FM Receiver Demo
    generate_options: qt_gui
    id: WBFM_RX
    output_language: python
    title: RTL-SDR WBFM Receiver
  states: {}

blocks:
- name: fm_station
  id: variable_qtgui_chooser
  parameters:
    label: FM Station
    label0: 91.1 Radio City
    label1: 93.5 Red FM
    label2: 94.3 Radio One
    label3: 98.3 Radio Mirchi
    label4: 102.9 Vividh Bharati
    num_opts: '5'
    option0: 91.1e6
    option1: 93.5e6
    option2: 94.3e6
    option3: 98.3e6
    option4: 102.9e6
    orient: Qt.QHBoxLayout
    type: real
    value: 91.1e6
    widget: radio_buttons
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      Selected for a wider baseband BW
      than FM signal BW of 200 kHz.
    value: '2048000'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '2'
    comment: |-
      Demodulates FM signal and
      decimates data rate.
    quad_rate: samp_rate
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    comment: Interface to speakers.
    samp_rate: '48000'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Links with audio_gain block 
      to adjust audio output volume.
    const: '0.5'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Adjusts output of RTL.
      Source to calibrate FFT sink.
    const: '0.00002'
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    comment: |-
      Limits data BW to FM
      signal information BW.
    cutoff_freq: 190e3
    decim: '2'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_ccf
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    comment: |-
      Decimates to audio rate
      and limits audio BW.
    cutoff_freq: 19e3
    decim: '10'
    gain: '0.5'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: fm_station
    fftsize: '1024'
    grid: 'True'
    type: complex
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    args: ''
    bb_gain0: '0'
    comment: Receiver "front end".
    dc_offset_mode0: '2'
    freq0: fm_station
    gain0: '30'
    gain_mode0: 'True'
    if_gain0: '2'
    iq_balance_mode0: '2'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_probe_rate_0, '0']
- [analog_wfm_rcv_0, '0', low_pass_filter_1, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_waterfall_sink_x_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [low_pass_filter_1, '0', blocks_multiply_const_vxx_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_const_vxx_1, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
